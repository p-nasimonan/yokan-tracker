# Repository p-nasimonan/yokan-tracker

File README.md:

# yokan-tracker

VRトラッカー用のKiCadプロジェクトです。

構成の出発点は以下です。

- MCU: XIAO ESP32-C6
- IMU: LSM6DSVモジュール
- 電源: LiPoバッテリー

## Gitでの管理方針

- 回路図、基板、プロジェクト設定はGitで追跡する
- `fp-info-cache` や `*.kicad_prl` のようなローカル状態は追跡しない
- カスタムフットプリントはこのリポジトリで管理する

## 現在の状態

- `XIAO-ESP32-C6-SMD.kicad_mod` を追加済み
- まだ回路図と基板レイアウトは未作成

## 次に決めること

1. LiPo充電をXIAOの内蔵回路で済ませるか、専用充電ICを追加するか
2. LSM6DSVの接続方法をモジュール前提にするか、素子直付けにするか
3. 3D実装のための基板外形、取付、コネクタ位置

## KiCad design yokan-tracker.kicad_pcb

Parts:
C1: 100nF; C_0402_1005Metric
U1: XIAO_ESP32_C6; XIAO-ESP32-C6-SMD
U2: LSM6DSV_Module

Connections:
+3V3: C1.1, U1.12 (3V3), U2.2 (3V3), U2.6 (CS)
GND: C1.2, U1.13 (GND), U2.1 (SDO/SA0), U2.3 (GND), U2.7 (SD0)
INT1: U1.2 (D1/INT1), U2.10 (INT1)
SCL: U1.6 (SCL/D5), U2.4 (SCL)
SDA: U1.5 (SDA/D4), U2.5 (SDA)

Notes on the sheet:
SlimeVR VRトラッカー / XIAO ESP32-C6 + LSM6DSV I2C
SlimeVR: 内部プルアップ使用(外部不要) バイパス: C1=100nF(0402) near U2 VCC
CS→+3V3: I2Cモード SDO/SD0→GND: addr=0x6A OCS,SCX,SDX,INT2: NC(未使用)
LiPo 3.7V 500mAh XIAO JST1.25直結 (BAT+/BAT- NC)

Board: 2 copper layers, 3 parts (0 on the bottom side), 5 nets, no tracks yet.

## Commit log (part)

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2026-05-26 バージョン対応
